# Keil uVision project fm33a0xx_FreeRTOS_template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A03XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fm33a0xx_FreeRTOS_template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __VTOR_PRESENT,__A04,__DEBUG
  c include: ..\fm33a0xx\Drivers;..\fm33a0xx\Include;..\FreeRTOS\ARM_CM0;..\FreeRTOS\Config;..\FreeRTOS\Source\include;..\UserCode\user_task;..\UserCode
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers
    ../fm33a0xx/Drivers/: fm33a0xx_aes.c fm33a0xx_anac.c fm33a0xx_btim.c fm33a0xx_crc.c fm33a0xx_dma.c fm33a0xx_etim.c fm33a0xx_flash.c fm33a0xx_gpio.c fm33a0xx_hspi.c fm33a0xx_i2c.c fm33a0xx_iwdt.c fm33a0xx_lcd.c fm33a0xx_lptim.c fm33a0xx_pmu.c fm33a0xx_rcc.c fm33a0xx_rtc.c fm33a0xx_scu.c fm33a0xx_spi.c fm33a0xx_trng.c fm33a0xx_u7816.c fm33a0xx_uart.c fm33a0xx_wwdt.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c timers.c
    ../FreeRTOS/ARM_CM0/: port.c
    ../FreeRTOS/MemMang/: heap_2.c
  group UserCode
    ../UserCode/: main.c user_init.c
    ../UserCode/user_task/: user_task.c
    ../FreeRTOS/Config/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
